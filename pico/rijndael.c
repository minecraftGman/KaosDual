/*
 * rijndael.c — AES-128 reference implementation.
 * Pure C, unchanged from the original KAOS project.
 * Works on any platform.
 */
#include "rijndael.h"
#include <string.h>

#define GETU32(p) ( ((uint32_t)(p)[0]<<24) ^ ((uint32_t)(p)[1]<<16) \
                  ^ ((uint32_t)(p)[2]<< 8) ^ ((uint32_t)(p)[3]) )
#define PUTU32(ct,st) { (ct)[0]=(uint8_t)((st)>>24); (ct)[1]=(uint8_t)((st)>>16); \
                        (ct)[2]=(uint8_t)((st)>>8);  (ct)[3]=(uint8_t)(st); }

/* Forward S-box */
static const uint8_t FSb[256] = {
    0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
    0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
    0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
    0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
    0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
    0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
    0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
    0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
    0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
    0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
    0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
    0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
    0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
    0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
    0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
    0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};

/* Inverse S-box */
static const uint8_t RSb[256] = {
    0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
    0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
    0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
    0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
    0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
    0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
    0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
    0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
    0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
    0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
    0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
    0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
    0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
    0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
    0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
    0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d
};

/* GF(2^8) multiply by 2 */
#define XTIME(x) ( ((x)<<1) ^ (((x)&0x80) ? 0x1b : 0x00) )
#define MUL(x,y) ( ((y)&1)*(x) ^ ((y)>>1&1)*XTIME(x) ^ ((y)>>2&1)*XTIME(XTIME(x)) \
                 ^ ((y)>>3&1)*XTIME(XTIME(XTIME(x))) ^ ((y)>>4&1)*XTIME(XTIME(XTIME(XTIME(x)))) )

static const uint32_t rcon[] = {
    0x01000000,0x02000000,0x04000000,0x08000000,0x10000000,
    0x20000000,0x40000000,0x80000000,0x1b000000,0x36000000
};

static uint32_t subword(uint32_t w) {
    return ((uint32_t)FSb[w>>24]<<24)|((uint32_t)FSb[(w>>16)&0xff]<<16)
          |((uint32_t)FSb[(w>>8)&0xff]<<8)|(uint32_t)FSb[w&0xff];
}
static uint32_t rotword(uint32_t w) { return (w<<8)|(w>>24); }

int rijndaelKeySetupEnc(uint32_t rk[], const uint8_t key[], int bits) {
    int i = 0;
    rk[0]=GETU32(key); rk[1]=GETU32(key+4); rk[2]=GETU32(key+8); rk[3]=GETU32(key+12);
    for(;;) {
        rk[4] = rk[0] ^ subword(rotword(rk[3])) ^ rcon[i];
        rk[5] = rk[1] ^ rk[4];
        rk[6] = rk[2] ^ rk[5];
        rk[7] = rk[3] ^ rk[6];
        if(++i == 10) return 10;
        rk += 4;
    }
    (void)bits;
}

int rijndaelKeySetupDec(uint32_t rk[], const uint8_t key[], int bits) {
    int Nr = rijndaelKeySetupEnc(rk, key, bits), i, j;
    uint32_t tmp;
    for(i=0,j=4*Nr; i<j; i+=4,j-=4) {
        tmp=rk[i];   rk[i]=rk[j];   rk[j]=tmp;
        tmp=rk[i+1]; rk[i+1]=rk[j+1]; rk[j+1]=tmp;
        tmp=rk[i+2]; rk[i+2]=rk[j+2]; rk[j+2]=tmp;
        tmp=rk[i+3]; rk[i+3]=rk[j+3]; rk[j+3]=tmp;
    }
    /* InvMixColumns on all but first and last round keys */
    for(i=1; i<Nr; i++) {
        rk += 4;
        uint8_t *b = (uint8_t*)rk;
        for(int col=0; col<4; col++,b+=4) {
            uint8_t s0=b[0],s1=b[1],s2=b[2],s3=b[3];
            b[0]=MUL(s0,0xe)^MUL(s1,0xb)^MUL(s2,0xd)^MUL(s3,0x9);
            b[1]=MUL(s0,0x9)^MUL(s1,0xe)^MUL(s2,0xb)^MUL(s3,0xd);
            b[2]=MUL(s0,0xd)^MUL(s1,0x9)^MUL(s2,0xe)^MUL(s3,0xb);
            b[3]=MUL(s0,0xb)^MUL(s1,0xd)^MUL(s2,0x9)^MUL(s3,0xe);
        }
    }
    return Nr;
}

void rijndaelEncrypt(const uint32_t rk[], int Nr, const uint8_t pt[16], uint8_t ct[16]) {
    uint8_t s[16], t[16]; int r;
    memcpy(s, pt, 16);
    for(int i=0;i<16;i++) s[i]^=((uint8_t*)rk)[i];
    for(r=1; r<Nr; r++) {
        rk+=4;
        for(int c=0;c<4;c++){
            int i=c*4;
            uint8_t s0=s[i],s1=s[i+1],s2=s[i+2],s3=s[i+3];
            /* This inner loop is intentionally simple for clarity */
            (void)s0;(void)s1;(void)s2;(void)s3;
        }
        /* Use FSb + MixColumns inline */
        for(int c=0;c<4;c++){
            uint8_t a=FSb[s[0+c]],b=FSb[s[4+((c+1)%4)]],
                    d=FSb[s[8+((c+2)%4)]],e=FSb[s[12+((c+3)%4)]];
            t[c*4+0]=XTIME(a)^(XTIME(b)^b)^d^e;
            t[c*4+1]=a^XTIME(b)^(XTIME(d)^d)^e;
            t[c*4+2]=a^b^XTIME(d)^(XTIME(e)^e);
            t[c*4+3]=(XTIME(a)^a)^b^d^XTIME(e);
        }
        uint8_t *rk8=(uint8_t*)(rk);
        for(int i=0;i<16;i++) s[i]=t[i]^rk8[i];
    }
    /* Final round (no MixColumns) */
    rk+=4; uint8_t *rk8=(uint8_t*)rk;
    ct[0] =FSb[s[0]] ^rk8[0];  ct[1] =FSb[s[5]] ^rk8[1];
    ct[2] =FSb[s[10]]^rk8[2];  ct[3] =FSb[s[15]]^rk8[3];
    ct[4] =FSb[s[4]] ^rk8[4];  ct[5] =FSb[s[9]] ^rk8[5];
    ct[6] =FSb[s[14]]^rk8[6];  ct[7] =FSb[s[3]] ^rk8[7];
    ct[8] =FSb[s[8]] ^rk8[8];  ct[9] =FSb[s[13]]^rk8[9];
    ct[10]=FSb[s[2]] ^rk8[10]; ct[11]=FSb[s[7]] ^rk8[11];
    ct[12]=FSb[s[12]]^rk8[12]; ct[13]=FSb[s[1]] ^rk8[13];
    ct[14]=FSb[s[6]] ^rk8[14]; ct[15]=FSb[s[11]]^rk8[15];
}

void rijndaelDecrypt(const uint32_t rk[], int Nr, const uint8_t ct[16], uint8_t pt[16]) {
    uint8_t s[16], t[16];
    memcpy(s, ct, 16);
    for(int i=0;i<16;i++) s[i]^=((uint8_t*)rk)[i];
    for(int r=1; r<Nr; r++){
        rk+=4; uint8_t *rk8=(uint8_t*)rk;
        /* InvShiftRows + InvSubBytes */
        t[0] =RSb[s[0]];  t[1] =RSb[s[13]]; t[2] =RSb[s[10]]; t[3] =RSb[s[7]];
        t[4] =RSb[s[4]];  t[5] =RSb[s[1]];  t[6] =RSb[s[14]]; t[7] =RSb[s[11]];
        t[8] =RSb[s[8]];  t[9] =RSb[s[5]];  t[10]=RSb[s[2]];  t[11]=RSb[s[15]];
        t[12]=RSb[s[12]]; t[13]=RSb[s[9]];  t[14]=RSb[s[6]];  t[15]=RSb[s[3]];
        /* InvMixColumns */
        for(int c=0;c<4;c++){
            uint8_t a=t[c*4],b=t[c*4+1],d=t[c*4+2],e=t[c*4+3];
            s[c*4+0]=MUL(a,0xe)^MUL(b,0xb)^MUL(d,0xd)^MUL(e,0x9);
            s[c*4+1]=MUL(a,0x9)^MUL(b,0xe)^MUL(d,0xb)^MUL(e,0xd);
            s[c*4+2]=MUL(a,0xd)^MUL(b,0x9)^MUL(d,0xe)^MUL(e,0xb);
            s[c*4+3]=MUL(a,0xb)^MUL(b,0xd)^MUL(d,0x9)^MUL(e,0xe);
        }
        for(int i=0;i<16;i++) s[i]^=rk8[i];
    }
    rk+=4; uint8_t *rk8=(uint8_t*)rk;
    pt[0] =RSb[s[0]] ^rk8[0];  pt[1] =RSb[s[13]]^rk8[1];
    pt[2] =RSb[s[10]]^rk8[2];  pt[3] =RSb[s[7]] ^rk8[3];
    pt[4] =RSb[s[4]] ^rk8[4];  pt[5] =RSb[s[1]] ^rk8[5];
    pt[6] =RSb[s[14]]^rk8[6];  pt[7] =RSb[s[11]]^rk8[7];
    pt[8] =RSb[s[8]] ^rk8[8];  pt[9] =RSb[s[5]] ^rk8[9];
    pt[10]=RSb[s[2]] ^rk8[10]; pt[11]=RSb[s[15]]^rk8[11];
    pt[12]=RSb[s[12]]^rk8[12]; pt[13]=RSb[s[9]] ^rk8[13];
    pt[14]=RSb[s[6]] ^rk8[14]; pt[15]=RSb[s[3]] ^rk8[15];
}
